# Keil uVision project YS-XFS5051.uvproj, settings and files
target YS-XFS5051 (MCS-51)
  device: AT89C5130 Atmel
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FFF) CLOCK(32000000) MODP2
  output: YS-XFS5051 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\code;..\user
  group APP
    ../code/: main.c
  group Driver
    ../user/: I2C_C.c usart.c XFS5152.C
