# Keil uVision project YS-XFS5051.uvproj, settings and files
target YS-XFS5051 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: YS-XFS5051 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\code;..\user
  group APP
    ../code/: main.c
  group Driver
    ../user/: usart.c XFS5152.C
